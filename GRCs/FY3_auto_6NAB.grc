<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>HA6NAB</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>FY3X Decoder</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>before_punc</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Bit delayer for depuncture</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[1, 2, 3, 4]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5e6</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>viterbi_dec_2th</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>1024*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79, 109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>viterbi_dec_2th_0</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>1024*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79, 109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>viterbi_dec_2th_1</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>1024*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79, 109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>viterbi_dec_2th_2</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>1024*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79, 109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>viterbi_dec_cc</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>1024*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79, 109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>viterbi_dec_cc_0</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>1024*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79, 109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>viterbi_dec_cc_1</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>1024*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79, 109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>viterbi_dec_cc_2</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>1024*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79, 109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1_0</value></param>
<param><key>delay</key><value>before_punc</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1_0_0</value></param>
<param><key>delay</key><value>before_punc</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1_0_0_0</value></param>
<param><key>delay</key><value>before_punc+1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1_0_0_0_0</value></param>
<param><key>delay</key><value>before_punc+2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1_0_0_0_1</value></param>
<param><key>delay</key><value>before_punc+3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1_0_1</value></param>
<param><key>delay</key><value>before_punc+1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1_0_1_0</value></param>
<param><key>delay</key><value>before_punc+2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1_0_1_1</value></param>
<param><key>delay</key><value>before_punc+3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/boci/Satellite-Decoders-master/FengYun Decoder/build/FY3B1.bin</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/boci/Satellite-Decoders-master/FengYun Decoder/build/FY3B1.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_1</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1_3</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are sync_block, basic_block, decim_block, interp_block
    

    def __init__(self):
 
        gr.sync_block.__init__(
            self,
            name='FY3X_diff.decoder_(HA6NAB_V1.3a)',
            in_sig=[np.byte, np.byte],
            out_sig=[np.byte, np.byte]
        )
        #self.set_history(2)
        self.ing0=[np.byte] #[np.uint8]
        self.ing0=0
        self.ing1=[np.byte]
        self.ing1=0

    def work(self, input_items, output_items):
        
        in0 = input_items[0][:]
        in1 = input_items[1][:]
        out0 = output_items[0][:]
        out1 = output_items[1][:]
        in_last0 = self.ing0
        in_last1 = self.ing1
        for i in range(0, len(in0)):
            in_act0 = in0[i]
            in_act1 = in1[i]
            if in_last0 == in_last1 :
                if in_last0 == in_act0 :
                    out0[i] = 0
                else:
                    out0[i] = 1
                if in_last1 == in_act1 :
                    out1[i] = 0
                else:
                    out1[i] = 1
            else:
                if in_last0 == in_act0 :
                    out1[i] = 0
                else:
                    out1[i] = 1
                if in_last1 == in_act1 :
                    out0[i] = 0
                else:
                    out0[i] = 1
            in_last0 = in_act0
            in_last1 = in_act1
        output_items[0][:] = out0[:]
        output_items[1][:] = out1[:]
        self.ing0 = in_last0
        self.ing1 = in_last1
        return len(output_items[0])</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_sync_diff</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
#import pmt
#from binascii import hexlify

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

    def __init__(self):
        
        gr.sync_block.__init__(
            self,
            name='FY3A/B/C_Self_Sync_Diff(HA6NAB:V1.2_19.09.10)',
            #in_sig=[np.float32, np.float32, np.float32, np.float32, np.float32, np.float32, np.float32, np.float32],
            #out_sig=[np.float32, np.float32]#, np.float32]
            in_sig=[np.uint8, np.uint8, np.uint8, np.uint8, np.uint8, np.uint8, np.uint8, np.uint8],
            out_sig=[np.uint8, np.uint8]
        )
        self.word_tar = 0
        self.word_tar0 = [np.uint32]
        self.word_tar0 = 0
        self.word_tar1 = [np.uint32]
        self.word_tar1 = 0
        self.word_tar2 = [np.uint32]
        self.word_tar2 = 0
        self.word_tar3 = [np.uint32]
        self.word_tar3 = 0
        self.hely = [np.uint8]
        self.hely = 0
        self.sync = [np.uint8]
        self.sync = 0
        self.sync_counter = [np.uint32]
        self.sync_counter = 0
        #self.sync_word = 0b00011010110011111111110000011101
        #self.sync_word = 0b11100101001100000000001111100010
        
        self.ing0=[np.uint8] #[np.uint8]
        self.ing0=0
        self.ing1=[np.uint8]
        self.ing1=0
        self.ing2=[np.uint8] #[np.uint8]
        self.ing2=0
        self.ing3=[np.uint8]
        self.ing3=0
        self.ing4=[np.uint8] #[np.uint8]
        self.ing4=0
        self.ing5=[np.uint8]
        self.ing5=0
        self.ing6=[np.uint8] #[np.uint8]
        self.ing6=0
        self.ing7=[np.uint8]
        self.ing7=0

        
    def work(self, input_items, output_items):
        word_tarx = self.word_tar
        word_tar0 = self.word_tar0
        word_tar1 = self.word_tar1
        word_tar2 = self.word_tar2
        word_tar3 = self.word_tar3
        
        ing0 = self.ing0
        ing1 = self.ing1
        ing0 = self.ing0
        ing1 = self.ing1
        ing2 = self.ing2
        ing3 = self.ing3
        ing4 = self.ing4
        ing5 = self.ing5
        ing6 = self.ing6
        ing7 = self.ing7
        #word_tar = self.word_tar
        hely = self.hely
        tar = hely
        sync = self.sync
        sync_counter = self.sync_counter
        out0 = output_items[0][:]
        out1 = output_items[1][:]
        out0[:] = 0
        out1[:] = 0
        for c in range(0, 4) :#4
            if (sync) :
                word_tar = word_tarx
                in_last0 = ing0
                in_last1 = ing1
            else:
                if (hely == 0) :
                    word_tar = word_tar0
                    in_last0 = ing0
                    in_last1 = ing1
                if (hely == 2) :
                    word_tar = word_tar1
                    in_last0 = ing2
                    in_last1 = ing3
                if (hely == 4) :
                    word_tar = word_tar2
                    in_last0 = ing4
                    in_last1 = ing5
                if (hely == 6) :
                    word_tar = word_tar3
                    in_last0 = ing6
                    in_last1 = ing7

            in0 = input_items[hely][:]
            in1 = input_items[hely + 1][:]
            for i in range(0, len(in0)) :

                if (sync) :
                    if (sync_counter &gt; 4080):
                        
                        in_act0 = in0[i]
                        in_act1 = in1[i]
                        if in_last0 == in_last1 :
                            if in_last0 == in_act0 :
                                outa = 0
                            else:
                                outa = 1
                            if in_last1 == in_act1 :
                                outb = 0
                            else:
                                outb = 1
                        else:
                            if in_last0 == in_act0 :
                                outb = 0
                            else:
                                outb = 1
                            if in_last1 == in_act1 :
                                outa = 0
                            else:
                                outa = 1
                        in_last0 = in_act0
                        in_last1 = in_act1
                        word_tar = word_tar &lt;&lt; 1
                        word_tar = word_tar &amp; 0b11111111111111111111110
                        if (outa):
                            word_tar = word_tar | 0b00000000000000000000001
                        if (word_tar == 0b00011010110011111111110) :#if (word_tar == 0b111001010011000000000011) :
                            sync_counter = (len(in0) - i) % 4096
                            in_last0 = ing0
                            in_last1 = ing1
                            for a in range(0, len(in0)):
                                
                                in_act0 = in0[a]
                                in_act1 = in1[a]
                                #if in_last0 != in_act0 :
                                #    if in_last0 == in_last1 :
                                #        out0[a] = 1
                                #    else:
                                #        out1[a] = 1
                                #if in_last1 != in_act1 :
                                #    if in_last0 == in_last1 :
                                #        out1[a] = 1
                                #    else:
                                #        out0[a] = 1   
                                if in_last0 == in_last1 :
                                    if in_last0 != in_act0 :
                                        out0[a] = 1
                                    if in_last1 != in_act1 :
                                        out1[a] = 1
                                else:
                                    if in_last0 != in_act0 :
                                        out1[a] = 1
                                    if in_last1 != in_act1 :
                                        out0[a] = 1
                                in_last0 = in_act0
                                in_last1 = in_act1
                            output_items[0][:] = out0[:]
                            output_items[1][:] = out1[:]
                            self.ing0 = in_last0
                            self.ing1 = in_last1
                            #self.word_tar = word_tar
                            self.sync = sync
                            self.sync_counter = sync_counter
                            self.hely = hely
                            return len(output_items[0])
                        word_tar = word_tar &lt;&lt; 1
                        word_tar = word_tar &amp; 0b11111111111111111111110
                        if (outb):
                            word_tar = word_tar | 0b00000000000000000000001
                        
                        if (word_tar == 0b00011010110011111111110) :#if (word_tar == 0b111001010011000000000011) :
                            sync_counter = (len(in0) - i) % 4096
                            in_last0 = ing0
                            in_last1 = ing1
                            for a in range(0, len(in0)):
                                
                                in_act0 = in0[a]
                                in_act1 = in1[a]
                                if in_last0 == in_last1 :
                                    if in_last0 != in_act0 :
                                        out0[a] = 1
                                    if in_last1 != in_act1 :
                                        out1[a] = 1
                                else:
                                    if in_last0 != in_act0 :
                                        out1[a] = 1
                                    if in_last1 != in_act1 :
                                        out0[a] = 1
                                #if in_last0 != in_act0 :
                                #    if in_last0 == in_last1 :
                                #        out0[a] = 1
                                #    else:
                                #        out1[a] = 1
                                #if in_last1 != in_act1 :
                                #    if in_last0 == in_last1 :
                                #        out1[a] = 1
                                #    else:
                                #        out0[a] = 1        
                                in_last0 = in_act0
                                in_last1 = in_act1
                            output_items[0][:] = out0[:]
                            output_items[1][:] = out1[:]
                            self.ing0 = in_last0
                            self.ing1 = in_last1
                            #self.word_tar = word_tar
                            self.sync = sync
                            self.sync_counter = sync_counter
                            self.hely = hely
                            return len(output_items[0])
                            
                        if (sync_counter &gt; 4096):
                            sync_counter = 0
                            sync = 0
                            i = 0
                    sync_counter = sync_counter + 1
                else:   #                                                       no sync... sync search
                    in_act0 = in0[i]
                    in_act1 = in1[i]
                    if in_last0 == in_last1 :
                        if in_last0 == in_act0 :
                            outa = 0
                        else:
                            outa = 1
                        if in_last1 == in_act1 :
                            outb = 0
                        else:
                            outb = 1
                    else:
                        if in_last0 == in_act0 :
                            outb = 0
                        else:
                            outb = 1
                        if in_last1 == in_act1 :
                            outa = 0
                        else:
                            outa = 1
                    in_last0 = in_act0
                    in_last1 = in_act1
                    word_tar = word_tar &lt;&lt; 1
                    word_tar = word_tar &amp; 0b11111111111111111111110
                    if (outa):
                        word_tar = word_tar | 0b00000000000000000000001
                    if (word_tar == 0b00011010110011111111110) :#if (word_tar == 0b111001010011000000000011) :#
                        sync = 1
                        sync_counter = (len(input_items[0]) - i) % 4096#8192 
                        in_last0 = ing0
                        in_last1 = ing1
                        for a in range(0, len(in0)):
                            in_act0 = in0[a]
                            in_act1 = in1[a]
                            
                            if in_last0 == in_last1 :
                                if in_last0 != in_act0 :
                                    out0[a] = 1
                                if in_last1 != in_act1 :
                                    out1[a] = 1
                            else:
                                if in_last0 != in_act0 :
                                    out1[a] = 1
                                if in_last1 != in_act1 :
                                    out0[a] = 1
                            in_last0 = in_act0
                            in_last1 = in_act1
                        output_items[0][:] = out0[:]
                        output_items[1][:] = out1[:]
                        self.ing0 = in_last0
                        self.ing1 = in_last1
                        
                        self.word_tar = word_tar
                        self.sync = sync
                        self.sync_counter = sync_counter
                        self.hely = hely
                        return len(output_items[0])
                    word_tar = word_tar &lt;&lt; 1
                    word_tar = word_tar &amp; 0b11111111111111111111110
                    if (outb):
                        word_tar = word_tar | 0b00000000000000000000001
                    if (word_tar == 0b00011010110011111111110) :#if (word_tar == 0b111001010011000000000011) :
                        sync = 1
                        sync_counter = (len(input_items[0]) - i) % 4096#8192 
                        in_last0 = ing0
                        in_last1 = ing1
                        for a in range(0, len(in0)):
                            in_act0 = in0[a]
                            in_act1 = in1[a]
                            if in_last0 == in_last1 :
                                if in_last0 != in_act0 :
                                    out0[a] = 1
                                if in_last1 != in_act1 :
                                    out1[a] = 1
                            else:
                                if in_last0 != in_act0 :
                                    out1[a] = 1
                                if in_last1 != in_act1 :
                                    out0[a] = 1
                            in_last0 = in_act0
                            in_last1 = in_act1
                        output_items[0][:] = out0[:]
                        output_items[1][:] = out1[:]
                        self.ing0 = in_last0
                        self.ing1 = in_last1
                        
                        self.word_tar = word_tar
                        self.sync = sync
                        self.sync_counter = sync_counter
                        self.hely = hely
                        return len(output_items[0])

            
            if (sync) :
                in_last0 = ing0
                in_last1 = ing1
                for a in range(0, len(in0)):
                    in_act0 = in0[a]
                    in_act1 = in1[a]
                    
                    if in_last0 == in_last1 :
                        if in_last0 != in_act0 :
                            out0[a] = 1
                        if in_last1 != in_act1 :
                            out1[a] = 1
                    else:
                        if in_last0 != in_act0 :
                            out1[a] = 1
                        if in_last1 != in_act1 :
                            out0[a] = 1        
                    in_last0 = in_act0            
                    in_last1 = in_act1            
                output_items[0][:] = out0[:]            
                output_items[1][:] = out1[:]
                self.ing0 = in_last0
                self.ing1 = in_last1
                
                self.word_tar = word_tar
                
                self.sync = sync
                self.sync_counter = sync_counter
                self.hely = hely
                return len(output_items[0])
            else:
                
                if (hely == 0) :
                    ing0 = in_last0
                    ing1 = in_last1
                    word_tar0 = word_tar
                if (hely == 2) :
                    word_tar1 = word_tar
                    ing2 = in_last0
                    ing3 = in_last1
                if (hely == 4) :
                    word_tar2 = word_tar
                    ing4 = in_last0
                    ing5 = in_last1
                if (hely == 6) :
                    word_tar3 = word_tar
                    ing6 = in_last0
                    ing7 = in_last1
                
                hely = hely + 2
                if (hely &gt; 7) :
                    hely = 0



        in0 = input_items[tar][:]
        in1 = input_items[tar + 1][:]
        in_last0 = ing0
        in_last1 = ing1

        for b in range(0, len(in0)):
            in_act0 = in0[b]
            in_act1 = in1[b]
                    
            if in_last0 == in_last1 :
                if in_last0 != in_act0 :
                    out0[b] = 1
                if in_last1 != in_act1 :
                    out1[b] = 1
            else:
                if in_last0 != in_act0 :
                    out1[b] = 1
                if in_last1 != in_act1 :
                    out0[b] = 1         
            in_last0 = in_act0            
            in_last1 = in_act1    


        output_items[0][:] = out0[:]            
        output_items[1][:] = out1[:]
        #self.ing0 = in_last0
        #self.ing1 = in_last1
        self.ing0 = ing0
        self.ing1 = ing1
        self.ing2 = ing2
        self.ing3 = ing3
        self.ing4 = ing4
        self.ing5 = ing5
        self.ing6 = ing6
        self.ing7 = ing7
        self.word_tar0 = word_tar0
        self.word_tar1 = word_tar1
        self.word_tar2 = word_tar2
        self.word_tar3 = word_tar3
        self.sync = 0#sync
        self.sync_counter = 0#sync_counter
        self.hely = tar#hely
        return len(input_items[0])</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0_0</value></param>
<param><key>comment</key><value>FEC 3/4</value></param>
<param><key>decoder_list</key><value>viterbi_dec_cc</value></param>
<param><key>puncpat</key><value>'110'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0_0_0</value></param>
<param><key>comment</key><value>FEC 3/4</value></param>
<param><key>decoder_list</key><value>viterbi_dec_cc_0</value></param>
<param><key>puncpat</key><value>'110'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0_0_0_0</value></param>
<param><key>comment</key><value>FEC 3/4</value></param>
<param><key>decoder_list</key><value>viterbi_dec_cc_1</value></param>
<param><key>puncpat</key><value>'110'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0_0_0_1</value></param>
<param><key>comment</key><value>FEC 3/4</value></param>
<param><key>decoder_list</key><value>viterbi_dec_cc_2</value></param>
<param><key>puncpat</key><value>'110'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0_0_1</value></param>
<param><key>comment</key><value>FEC 3/4</value></param>
<param><key>decoder_list</key><value>viterbi_dec_2th</value></param>
<param><key>puncpat</key><value>'110'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0_0_1_0</value></param>
<param><key>comment</key><value>FEC 3/4</value></param>
<param><key>decoder_list</key><value>viterbi_dec_2th_0</value></param>
<param><key>puncpat</key><value>'110'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0_0_1_0_0</value></param>
<param><key>comment</key><value>FEC 3/4</value></param>
<param><key>decoder_list</key><value>viterbi_dec_2th_1</value></param>
<param><key>puncpat</key><value>'110'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0_0_1_0_1</value></param>
<param><key>comment</key><value>FEC 3/4</value></param>
<param><key>decoder_list</key><value>viterbi_dec_2th_2</value></param>
<param><key>puncpat</key><value>'110'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, os</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>1,2,2,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"dark red"</value></param>
<param><key>label1</key><value>Constellation diagram</value></param>
<param><key>marker1</key><value>1</value></param>
<param><key>name</key><value>FENGYUN3</value></param>
<param><key>size</key><value>512</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0</value></param>
<param><key>gui_hint</key><value>4,0,1,4</value></param>
<param><key>zmin</key><value>0</value></param>
<param><key>ncols</key><value>8192</value></param>
<param><key>nrows</key><value>64</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_1_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_1_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_1_0_1_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_1_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_1_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1_0</source_block_id><sink_block_id>fec_extended_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1_0_0</source_block_id><sink_block_id>fec_extended_decoder_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1_0_0_0</source_block_id><sink_block_id>fec_extended_decoder_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1_0_0_0_0</source_block_id><sink_block_id>fec_extended_decoder_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1_0_0_0_1</source_block_id><sink_block_id>fec_extended_decoder_0_0_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1_0_1</source_block_id><sink_block_id>fec_extended_decoder_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1_0_1_0</source_block_id><sink_block_id>fec_extended_decoder_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1_0_1_1</source_block_id><sink_block_id>fec_extended_decoder_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_1</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_1</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_sync_diff</source_block_id><sink_block_id>blocks_interleave_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_sync_diff</source_block_id><sink_block_id>blocks_interleave_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0_0</source_block_id><sink_block_id>epy_block_sync_diff</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0_0_0</source_block_id><sink_block_id>epy_block_sync_diff</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0_0_0_0</source_block_id><sink_block_id>epy_block_sync_diff</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0_0_0_1</source_block_id><sink_block_id>epy_block_sync_diff</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0_0_1</source_block_id><sink_block_id>epy_block_sync_diff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0_0_1_0</source_block_id><sink_block_id>epy_block_sync_diff</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0_0_1_0_0</source_block_id><sink_block_id>epy_block_sync_diff</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0_0_1_0_1</source_block_id><sink_block_id>epy_block_sync_diff</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
</flow_graph>
