<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>HA6NAB</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Metop_auto_decoder</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>before_punc</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Bit delayer for depuncture</value></param>
<param><key>labels</key><value>["1 bit delay", "2 bit delay"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[1, 2]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>before_punc</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>deg_rotation</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>______0 - 90 deg rotation</value></param>
<param><key>labels</key><value>["0 deg", "90 deg"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[1, 1j]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>record_en</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Record Eneble</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>5e6</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>viterbi_dec_cc</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>1024*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79, 109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>viterbi_dec_cc_0</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>1024*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79, 109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>viterbi_dec_cc_1</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>1024*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79, 109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>viterbi_dec_cc_2</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>1024*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79, 109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>output_index</key><value>record_en</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>comment</key><value>set:1,2.</value></param>
<param><key>delay</key><value>before_punc</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>comment</key><value>set:1,2.</value></param>
<param><key>delay</key><value>before_punc</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0</value></param>
<param><key>comment</key><value>set:1,2.</value></param>
<param><key>delay</key><value>before_punc+1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_1</value></param>
<param><key>comment</key><value>set:1,2.</value></param>
<param><key>delay</key><value>before_punc</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_2</value></param>
<param><key>comment</key><value>set:1,2.</value></param>
<param><key>delay</key><value>before_punc+1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1</value></param>
<param><key>comment</key><value>set:1,2.</value></param>
<param><key>delay</key><value>before_punc+1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_2</value></param>
<param><key>comment</key><value>set:1,2.</value></param>
<param><key>delay</key><value>before_punc</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_3</value></param>
<param><key>comment</key><value>set:1,2.</value></param>
<param><key>delay</key><value>before_punc+1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>D:\rawok\Metop\MetopB_2020-07-18_095100.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>D:\rawok\Metop\MetopB_2020-07-18_095100.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>comment</key><value>90° phase rotator</value></param>
<param><key>const</key><value>deg_rotation</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>comment</key><value>90° phase rotating.</value></param>
<param><key>const</key><value>1j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_patterned_interleaver</key>
<param><key>id</key><value>blocks_patterned_interleaver_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>pattern</key><value>[0,1,1,0]</value></param>
</block>
<block>
<key>blocks_patterned_interleaver</key>
<param><key>id</key><value>blocks_patterned_interleaver_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>pattern</key><value>[0,1,1,0]</value></param>
</block>
<block>
<key>blocks_patterned_interleaver</key>
<param><key>id</key><value>blocks_patterned_interleaver_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>pattern</key><value>[0,1,1,0]</value></param>
</block>
<block>
<key>blocks_patterned_interleaver</key>
<param><key>id</key><value>blocks_patterned_interleaver_0_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>pattern</key><value>[0,1,1,0]</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1_4</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
#import pmt
#from binascii import hexlify

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

    def __init__(self):
        
        gr.sync_block.__init__(
            self,
            name='MetopA,B,C_Self_Sync (HA6NAB:V1.4_19.09.03)',
            in_sig=[np.uint8, np.uint8, np.uint8, np.uint8],
            out_sig=[np.uint8]#, np.float32]
        )
        
        self.word_tar = 0
        self.word_tar0 = [np.uint32]
        self.word_tar0 = 0
        self.word_tar1 = [np.uint32]
        self.word_tar1 = 0
        self.word_tar2 = [np.uint32]
        self.word_tar2 = 0
        self.word_tar3 = [np.uint32]
        self.word_tar3 = 0
        self.hely = [np.uint8]
        self.hely = 0
        #self.tar = 0
        #self.sync_word = [np.uint32]
        self.sync = [np.uint8]
        self.sync = 0
        self.sync_counter = [np.uint32]
        self.sync_counter = 0
        #self.sync_word = 0b00011010110011111111110000011101
        #self.sync_word = 0b11100101001100000000001111100010

        
    def work(self, input_items, output_items):
        #out0 = output_items[0]
        #tar = self.tar
        #word_tar = self.word_tar
        word_tar0 = self.word_tar0
        word_tar1 = self.word_tar1
        word_tar2 = self.word_tar2
        word_tar3 = self.word_tar3
        hely = self.hely
        tar = hely
        sync = self.sync
        #sync_word = self.sync_word
        #in0 = input_items[hely]
        sync_counter = self.sync_counter
        for c in range(0, 4):
            if (sync) :
                word_tar = self.word_tar
            else:
                if (hely == 0) :
                    word_tar = word_tar0
                if (hely == 1) :
                    word_tar = word_tar1
                if (hely == 2) :
                    word_tar = word_tar2
                if (hely == 3) :
                    word_tar = word_tar3
            in0 = input_items[hely][:]
            for i in range(0, len(input_items[0])) :
                if (sync) :
                    if (sync_counter &gt; 8166):#8167
                        word_tar = word_tar &lt;&lt; 1
                        word_tar = word_tar &amp; 0b0111111111111111111111110
                        if (in0[i]) :
                            word_tar = word_tar | 0b000000000000000000000001
                        if (word_tar == 0b111001010011000000000011) :
                            sync_counter = (len(input_items[0]) - i) % 8192 
                            output_items[0][:] = in0[:]
                            self.word_tar = word_tar
                            self.sync = sync
                            self.sync_counter = sync_counter
                            self.hely = hely
                            return len(output_items[0])                        
                        else:
                            if (word_tar == 0b000110101100111111111100) :
                                sync_counter = (len(input_items[0]) - i) % 8192 
                                output_items[0][:] = in0[:]
                                self.word_tar = word_tar
                                self.sync = sync
                                self.sync_counter = sync_counter
                                self.hely = hely
                                return len(output_items[0])
                        if (sync_counter &gt; 8192):#8192
                            sync_counter = 0
                            sync = 0
                            i = 0
                    sync_counter = sync_counter + 1
                else:
                    word_tar = word_tar &lt;&lt; 1
                    word_tar = word_tar &amp; 0b0111111111111111111111110
                    if (in0[i]):
                        word_tar = word_tar | 0b000000000000000000000001
                    if (word_tar == 0b111001010011000000000011) :#
                        sync = 1
                        sync_counter = (len(input_items[0]) - i) % 8192 
                        output_items[0][:] = in0[:]
                        #self.word_tar = word_tar
                        self.sync = sync
                        self.sync_counter = sync_counter
                        self.hely = hely
                        return len(output_items[0])
                    else:
                        if (word_tar == 0b000110101100111111111100) :
                            sync = 1
                            sync_counter = (len(input_items[0]) - i) % 8192 
                            output_items[0][:] = in0[:]
                            #self.word_tar = word_tar
                            self.sync = sync
                            self.sync_counter = sync_counter
                            self.hely = hely
                            return len(output_items[0])
            if (hely == 0) :
                word_tar0 = word_tar
            if (hely == 1) :
                word_tar1 = word_tar
            if (hely == 2) :
                word_tar2 = word_tar
            if (hely == 3) :
                word_tar3 = word_tar
            if (sync) :
                output_items[0][:] = in0[:]
                self.word_tar = word_tar
                self.sync = sync
                self.sync_counter = sync_counter
                self.hely = hely
                return len(output_items[0])
            else:
                hely = hely + 1
                if (hely &gt; 3) :
                    hely = 0
        output_items[0][:] = input_items[tar][:]
        self.word_tar0 = word_tar0
        self.word_tar1 = word_tar1
        self.word_tar2 = word_tar2
        self.word_tar3 = word_tar3
        self.sync = 0#sync
        self.sync_counter = 0#sync_counter
        self.hely = tar#hely
        return len(output_items[0])
</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0_0</value></param>
<param><key>decoder_list</key><value>viterbi_dec_cc</value></param>
<param><key>puncpat</key><value>'110110'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0_0_0</value></param>
<param><key>decoder_list</key><value>viterbi_dec_cc_0</value></param>
<param><key>puncpat</key><value>'110110'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0_0_1</value></param>
<param><key>decoder_list</key><value>viterbi_dec_cc_1</value></param>
<param><key>puncpat</key><value>'110110'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0_0_2</value></param>
<param><key>decoder_list</key><value>viterbi_dec_cc_2</value></param>
<param><key>puncpat</key><value>'110110'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, os</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>1,2,2,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"dark red"</value></param>
<param><key>label1</key><value>Constellation diagram</value></param>
<param><key>marker1</key><value>1</value></param>
<param><key>name</key><value>METOP</value></param>
<param><key>size</key><value>512</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0</value></param>
<param><key>gui_hint</key><value>3,0,1,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>zmin</key><value>0</value></param>
<param><key>ncols</key><value>8192</value></param>
<param><key>nrows</key><value>64</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>3,0,1,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>ncols</key><value>8192</value></param>
<param><key>nrows</key><value>64</value></param>
<param><key>samp_rate</key><value>4e6</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_3</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_delay_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_patterned_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_patterned_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0</source_block_id><sink_block_id>blocks_patterned_interleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_1</source_block_id><sink_block_id>blocks_patterned_interleaver_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_2</source_block_id><sink_block_id>blocks_patterned_interleaver_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1</source_block_id><sink_block_id>blocks_patterned_interleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_2</source_block_id><sink_block_id>blocks_patterned_interleaver_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_3</source_block_id><sink_block_id>blocks_patterned_interleaver_0_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_complex_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_patterned_interleaver_0</source_block_id><sink_block_id>fec_extended_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_patterned_interleaver_0_0</source_block_id><sink_block_id>fec_extended_decoder_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_patterned_interleaver_0_1</source_block_id><sink_block_id>fec_extended_decoder_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_patterned_interleaver_0_2</source_block_id><sink_block_id>fec_extended_decoder_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1_4</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1_4</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0_0</source_block_id><sink_block_id>epy_block_1_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0_0_0</source_block_id><sink_block_id>epy_block_1_4</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0_0_1</source_block_id><sink_block_id>epy_block_1_4</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0_0_2</source_block_id><sink_block_id>epy_block_1_4</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
</flow_graph>
