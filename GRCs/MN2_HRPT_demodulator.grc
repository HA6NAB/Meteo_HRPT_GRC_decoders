<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>MN2, MN2-2 HRPT Demodulator</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>comment</key><value>mn2 &amp; mn2-2:  1700MHz</value></param>
<param><key>value</key><value>1700.0e6</value></param>
<param><key>gui_hint</key><value>0,0,1,3</value></param>
<param><key>label</key><value>Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1690.0e6</value></param>
<param><key>step</key><value>1e2</value></param>
<param><key>stop</key><value>1708e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>clock_alpha</value></param>
<param><key>comment</key><value>13.8e-3</value></param>
<param><key>value</key><value>7.3e-3</value></param>
<param><key>gui_hint</key><value>0,6,1,1</value></param>
<param><key>label</key><value>Clock Alpha</value></param>
<param><key>min_len</key><value>150</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e-3</value></param>
<param><key>step</key><value>1e-5</value></param>
<param><key>stop</key><value>50e-3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>filtgain_0</value></param>
<param><key>value</key><value>1.8e6</value></param>
<param><key>gui_hint</key><value>0,5,1,1</value></param>
<param><key>label</key><value>Filter Gain</value></param>
<param><key>min_len</key><value>150</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e6</value></param>
<param><key>step</key><value>1e4</value></param>
<param><key>stop</key><value>3.3e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hs</value></param>
<param><key>value</key><value>int(sps/2.0)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lnagain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,7,1,1</value></param>
<param><key>label</key><value>LNA Gain</value></param>
<param><key>min_len</key><value>150</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>15</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>mixgain</value></param>
<param><key>value</key><value>28</value></param>
<param><key>gui_hint</key><value>0,8,1,1</value></param>
<param><key>label</key><value>Mixer Gain</value></param>
<param><key>min_len</key><value>150</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>pll_alpha</value></param>
<param><key>value</key><value>0.010</value></param>
<param><key>gui_hint</key><value>0,4,1,1</value></param>
<param><key>label</key><value>PLL Alpha</value></param>
<param><key>min_len</key><value>150</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.00100</value></param>
<param><key>step</key><value>0.00001</value></param>
<param><key>stop</key><value>0.10000</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>record_en</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Record Enable</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3.4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>(samp_rate*1.0)/(symbol_rate*1.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>comment</key><value>600*1109</value></param>
<param><key>value</key><value>600*1109</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vgagain</value></param>
<param><key>value</key><value>40</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label</key><value>VGA Gain</value></param>
<param><key>min_len</key><value>150</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>0.5/32768.0</value></param>
<param><key>max_gain</key><value>5000</value></param>
<param><key>rate</key><value>0.5e-3</value></param>
<param><key>reference</key><value>1.1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>0.08</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>output_index</key><value>record_en</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>hs</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0/hs</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_0</value></param>
<param><key>length</key><value>16384</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>clock_alpha</value></param>
<param><key>gain_omega</key><value>clock_alpha**2/4.0</value></param>
<param><key>mu</key><value>1.0</value></param>
<param><key>omega_relative_limit</key><value>max_clock_offset</value></param>
<param><key>omega</key><value>sps/2.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>frames_file_sink</value></param>
<param><key>file</key><value>\MN2\MN22_2020-08-09_123400.bin</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_carrier_offset</value></param>
<param><key>label</key><value>MaxCarrierOffset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_clock_offset</value></param>
<param><key>label</key><value>MaxClockOffset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.01</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>mixgain</value></param>
<param><key>dc_offset_mode0</key><value>1</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>vgagain</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>lnagain</value></param>
<param><key>args</key><value>hackrf=2374cd</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>noaa_hrpt_pll_cf</key>
<param><key>id</key><value>pll</value></param>
<param><key>alpha</key><value>pll_alpha</value></param>
<param><key>beta</key><value>pll_alpha**2/4.0</value></param>
<param><key>max_offset</key><value>max_carrier_offset</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>2,0,1,10</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"dark red"</value></param>
<param><key>label1</key><value>10</value></param>
<param><key>name</key><value>Output Constellation</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>512</value></param>
<param><key>gui_hint</key><value>3,0,1,10</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"black"</value></param>
<param><key>width1</key><value>3</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>wintype</key><value>firdes.WIN_RECTANGULAR</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-60</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>interp</key><value>2</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>comment</key><value>symbol_rate*2.2
num_taps 361
alpha 0.4</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>512</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>filtgain_0</value></param>
</block>
<block>
<key>sdrplay_rsp1_source</key>
<param><key>id</key><value>sdrplay_rsp1_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>agc_enabled</key><value>False</value></param>
<param><key>bw</key><value>5000</value></param>
<param><key>dc_offset_mode</key><value>True</value></param>
<param><key>debug_enabled</key><value>False</value></param>
<param><key>device_serial</key><value>'0'</value></param>
<param><key>ifType</key><value>0</value></param>
<param><key>if_atten_db</key><value>mixgain</value></param>
<param><key>iq_balance_mode</key><value>True</value></param>
<param><key>lna_atten_step</key><value>True</value></param>
<param><key>lo_mode</key><value>1</value></param>
<param><key>rf_freq</key><value>center_freq</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>frames_file_sink</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>dc_blocker_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pll</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>pll</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rsp1_source_0</source_block_id><sink_block_id>dc_blocker_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
